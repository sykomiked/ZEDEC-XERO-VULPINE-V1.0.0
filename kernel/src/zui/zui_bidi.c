/* Copyright (c) 2024-2026 Michael Laurence Curzi and 36N9 Genetics, LLC */
/* SPDX-License-Identifier: Apache-2.0 */
/* Tables and test data derived from the Unicode Character Database / CLDR,
 * Copyright (c) Unicode, Inc., under the Unicode License v3
 * (https://www.unicode.org/license.txt). */
/* zui_bidi.c — the Unicode Bidirectional Algorithm (zui_bidi.h B1..B9).
 *
 * The tables below are generated from the Unicode 15.1 character database
 * (DerivedBidiClass.txt, BidiMirroring.txt, BidiBrackets.txt). */
#include "zui_bidi.h"

#define NONE 0xFFFFu

enum {
    L = ZUI_BIDI_L,
    R = ZUI_BIDI_R,
    AL = ZUI_BIDI_AL,
    EN = ZUI_BIDI_EN,
    ES = ZUI_BIDI_ES,
    ET = ZUI_BIDI_ET,
    AN = ZUI_BIDI_AN,
    CS = ZUI_BIDI_CS,
    NSM = ZUI_BIDI_NSM,
    BN = ZUI_BIDI_BN,
    B = ZUI_BIDI_B,
    S = ZUI_BIDI_S,
    WS = ZUI_BIDI_WS,
    ON = ZUI_BIDI_ON,
    LRE = ZUI_BIDI_LRE,
    LRO = ZUI_BIDI_LRO,
    RLE = ZUI_BIDI_RLE,
    RLO = ZUI_BIDI_RLO,
    PDF = ZUI_BIDI_PDF,
    LRI = ZUI_BIDI_LRI,
    RLI = ZUI_BIDI_RLI,
    FSI = ZUI_BIDI_FSI,
    PDI = ZUI_BIDI_PDI
};

// clang-format off
/* 1200 ranges: (first code point << 5) | class; a range runs to the next one. */
static const uint32_t BIDI_RANGES[1200] = {
    0x9, 0x12b, 0x14a, 0x16b, 0x18c, 0x1aa, 0x1c9, 0x38a, 0x3eb,
    0x40c, 0x42d, 0x465, 0x4cd, 0x564, 0x587, 0x5a4, 0x5c7, 0x603,
    0x747, 0x76d, 0x820, 0xb6d, 0xc20, 0xf6d, 0xfe9, 0x10aa, 0x10c9,
    0x1407, 0x142d, 0x1445, 0x14cd, 0x1540, 0x156d, 0x15a9, 0x15cd, 0x1605,
    0x1643, 0x168d, 0x16a0, 0x16cd, 0x1723, 0x1740, 0x176d, 0x1800, 0x1aed,
    0x1b00, 0x1eed, 0x1f00, 0x572d, 0x5760, 0x584d, 0x5a00, 0x5a4d, 0x5c00,
    0x5cad, 0x5dc0, 0x5ded, 0x6008, 0x6e00, 0x6e8d, 0x6ec0, 0x6fcd, 0x6fe0,
    0x708d, 0x70c0, 0x70ed, 0x7100, 0x7ecd, 0x7ee0, 0x9068, 0x9140, 0xb14d,
    0xb160, 0xb1ad, 0xb1e5, 0xb201, 0xb228, 0xb7c1, 0xb7e8, 0xb801, 0xb828,
    0xb861, 0xb888, 0xb8c1, 0xb8e8, 0xb901, 0xc006, 0xc0cd, 0xc102, 0xc125,
    0xc162, 0xc187, 0xc1a2, 0xc1cd, 0xc208, 0xc362, 0xc968, 0xcc06, 0xcd45,
    0xcd66, 0xcda2, 0xce08, 0xce22, 0xdac8, 0xdba6, 0xdbcd, 0xdbe8, 0xdca2,
    0xdce8, 0xdd2d, 0xdd48, 0xddc2, 0xde03, 0xdf42, 0xe228, 0xe242, 0xe608,
    0xe962, 0xf4c8, 0xf622, 0xf801, 0xfd68, 0xfe81, 0xfecd, 0xff41, 0xffa8,
    0xffc1, 0x102c8, 0x10341, 0x10368, 0x10481, 0x104a8, 0x10501, 0x10528, 0x105c1,
    0x10b28, 0x10b81, 0x10c02, 0x11206, 0x11242, 0x11308, 0x11402, 0x11948, 0x11c46,
    0x11c68, 0x12060, 0x12748, 0x12760, 0x12788, 0x127a0, 0x12828, 0x12920, 0x129a8,
    0x129c0, 0x12a28, 0x12b00, 0x12c48, 0x12c80, 0x13028, 0x13040, 0x13788, 0x137a0,
    0x13828, 0x138a0, 0x139a8, 0x139c0, 0x13c48, 0x13c80, 0x13e45, 0x13e80, 0x13f65,
    0x13f80, 0x13fc8, 0x13fe0, 0x14028, 0x14060, 0x14788, 0x147a0, 0x14828, 0x14860,
    0x148e8, 0x14920, 0x14968, 0x149c0, 0x14a28, 0x14a40, 0x14e08, 0x14e40, 0x14ea8,
    0x14ec0, 0x15028, 0x15060, 0x15788, 0x157a0, 0x15828, 0x158c0, 0x158e8, 0x15920,
    0x159a8, 0x159c0, 0x15c48, 0x15c80, 0x15e25, 0x15e40, 0x15f48, 0x16000, 0x16028,
    0x16040, 0x16788, 0x167a0, 0x167e8, 0x16800, 0x16828, 0x168a0, 0x169a8, 0x169c0,
    0x16aa8, 0x16ae0, 0x16c48, 0x16c80, 0x17048, 0x17060, 0x17808, 0x17820, 0x179a8,
    0x179c0, 0x17e6d, 0x17f25, 0x17f4d, 0x17f60, 0x18008, 0x18020, 0x18088, 0x180a0,
    0x18788, 0x187a0, 0x187c8, 0x18820, 0x188c8, 0x18920, 0x18948, 0x189c0, 0x18aa8,
    0x18ae0, 0x18c48, 0x18c80, 0x18f0d, 0x18fe0, 0x19028, 0x19040, 0x19788, 0x197a0,
    0x19988, 0x199c0, 0x19c48, 0x19c80, 0x1a008, 0x1a040, 0x1a768, 0x1a7a0, 0x1a828,
    0x1a8a0, 0x1a9a8, 0x1a9c0, 0x1ac48, 0x1ac80, 0x1b028, 0x1b040, 0x1b948, 0x1b960,
    0x1ba48, 0x1baa0, 0x1bac8, 0x1bae0, 0x1c628, 0x1c640, 0x1c688, 0x1c760, 0x1c7e5,
    0x1c800, 0x1c8e8, 0x1c9e0, 0x1d628, 0x1d640, 0x1d688, 0x1d7a0, 0x1d908, 0x1d9e0,
    0x1e308, 0x1e340, 0x1e6a8, 0x1e6c0, 0x1e6e8, 0x1e700, 0x1e728, 0x1e74d, 0x1e7c0,
    0x1ee28, 0x1efe0, 0x1f008, 0x1f0a0, 0x1f0c8, 0x1f100, 0x1f1a8, 0x1f300, 0x1f328,
    0x1f7a0, 0x1f8c8, 0x1f8e0, 0x205a8, 0x20620, 0x20648, 0x20700, 0x20728, 0x20760,
    0x207a8, 0x207e0, 0x20b08, 0x20b40, 0x20bc8, 0x20c20, 0x20e28, 0x20ea0, 0x21048,
    0x21060, 0x210a8, 0x210e0, 0x211a8, 0x211c0, 0x213a8, 0x213c0, 0x26ba8, 0x26c00,
    0x2720d, 0x27340, 0x2800d, 0x28020, 0x2d00c, 0x2d020, 0x2d36d, 0x2d3a0, 0x2e248,
    0x2e2a0, 0x2e648, 0x2e680, 0x2ea48, 0x2ea80, 0x2ee48, 0x2ee80, 0x2f688, 0x2f6c0,
    0x2f6e8, 0x2f7c0, 0x2f8c8, 0x2f8e0, 0x2f928, 0x2fa80, 0x2fb65, 0x2fb80, 0x2fba8,
    0x2fbc0, 0x2fe0d, 0x2ff40, 0x3000d, 0x30168, 0x301c9, 0x301e8, 0x30200, 0x310a8,
    0x310e0, 0x31528, 0x31540, 0x32408, 0x32460, 0x324e8, 0x32520, 0x32648, 0x32660,
    0x32728, 0x32780, 0x3280d, 0x32820, 0x3288d, 0x328c0, 0x33bcd, 0x34000, 0x342e8,
    0x34320, 0x34368, 0x34380, 0x34ac8, 0x34ae0, 0x34b08, 0x34be0, 0x34c08, 0x34c20,
    0x34c48, 0x34c60, 0x34ca8, 0x34da0, 0x34e68, 0x34fa0, 0x34fe8, 0x35000, 0x35608,
    0x359e0, 0x36008, 0x36080, 0x36688, 0x366a0, 0x366c8, 0x36760, 0x36788, 0x367a0,
    0x36848, 0x36860, 0x36d68, 0x36e80, 0x37008, 0x37040, 0x37448, 0x374c0, 0x37508,
    0x37540, 0x37568, 0x375c0, 0x37cc8, 0x37ce0, 0x37d08, 0x37d40, 0x37da8, 0x37dc0,
    0x37de8, 0x37e40, 0x38588, 0x38680, 0x386c8, 0x38700, 0x39a08, 0x39a60, 0x39a88,
    0x39c20, 0x39c48, 0x39d20, 0x39da8, 0x39dc0, 0x39e88, 0x39ea0, 0x39f08, 0x39f40,
    0x3b808, 0x3c000, 0x3f7ad, 0x3f7c0, 0x3f7ed, 0x3f840, 0x3f9ad, 0x3fa00, 0x3fbad,
    0x3fc00, 0x3fdad, 0x3fe00, 0x3ffad, 0x3ffe0, 0x4000c, 0x40169, 0x401c0, 0x401e1,
    0x4020d, 0x4050c, 0x4052a, 0x4054e, 0x40570, 0x40592, 0x405af, 0x405d1, 0x405e7,
    0x40605, 0x406ad, 0x40887, 0x408ad, 0x40bec, 0x40c09, 0x40cd3, 0x40cf4, 0x40d15,
    0x40d36, 0x40d49, 0x40e03, 0x40e20, 0x40e83, 0x40f44, 0x40f8d, 0x40fe0, 0x41003,
    0x41144, 0x4118d, 0x411e0, 0x41405, 0x41a08, 0x41e20, 0x4200d, 0x42040, 0x4206d,
    0x420e0, 0x4210d, 0x42140, 0x4228d, 0x422a0, 0x422cd, 0x42320, 0x423cd, 0x42480,
    0x424ad, 0x424c0, 0x424ed, 0x42500, 0x4252d, 0x42540, 0x425c5, 0x425e0, 0x4274d,
    0x42780, 0x4280d, 0x428a0, 0x4294d, 0x429c0, 0x42a0d, 0x42c00, 0x4312d, 0x43180,
    0x4320d, 0x44244, 0x44265, 0x4428d, 0x466c0, 0x46f6d, 0x472a0, 0x472cd, 0x484e0,
    0x4880d, 0x48960, 0x48c0d, 0x49103, 0x49380, 0x49d4d, 0x4d580, 0x4d5ad, 0x50000,
    0x5200d, 0x56e80, 0x56ecd, 0x572c0, 0x572ed, 0x58000, 0x59cad, 0x59d60, 0x59de8,
    0x59e40, 0x59f2d, 0x5a000, 0x5afe8, 0x5b000, 0x5bc08, 0x5c00d, 0x5cbc0, 0x5d00d,
    0x5d340, 0x5d36d, 0x5de80, 0x5e00d, 0x5fac0, 0x5fe0d, 0x6000c, 0x6002d, 0x600a0,
    0x6010d, 0x60420, 0x60548, 0x605c0, 0x6060d, 0x60620, 0x606cd, 0x60700, 0x607ad,
    0x60800, 0x61328, 0x6136d, 0x613a0, 0x6140d, 0x61420, 0x61f6d, 0x61f80, 0x6380d,
    0x63c80, 0x63ded, 0x63e00, 0x643ad, 0x643e0, 0x64a0d, 0x64c00, 0x64f8d, 0x64fe0,
    0x6562d, 0x65800, 0x6598d, 0x65a00, 0x66eed, 0x66f60, 0x67bcd, 0x67c00, 0x67fed,
    0x68000, 0x9b80d, 0x9c000, 0x14920d, 0x1498e0, 0x14c1ad, 0x14c200, 0x14cde8, 0x14ce6d,
    0x14ce88, 0x14cfcd, 0x14d000, 0x14d3c8, 0x14d400, 0x14de08, 0x14de40, 0x14e00d, 0x14e440,
    0x14f10d, 0x14f120, 0x150048, 0x150060, 0x1500c8, 0x1500e0, 0x150168, 0x150180, 0x1504a8,
    0x1504e0, 0x15050d, 0x150588, 0x1505a0, 0x150705, 0x150740, 0x150e8d, 0x150f00, 0x151888,
    0x1518c0, 0x151c08, 0x151e40, 0x151fe8, 0x152000, 0x1524c8, 0x1525c0, 0x1528e8, 0x152a40,
    0x153008, 0x153060, 0x153668, 0x153680, 0x1536c8, 0x153740, 0x153788, 0x1537c0, 0x153ca8,
    0x153cc0, 0x154528, 0x1545e0, 0x154628, 0x154660, 0x1546a8, 0x1546e0, 0x154868, 0x154880,
    0x154988, 0x1549a0, 0x154f88, 0x154fa0, 0x155608, 0x155620, 0x155648, 0x1556a0, 0x1556e8,
    0x155720, 0x1557c8, 0x155800, 0x155828, 0x155840, 0x155d88, 0x155dc0, 0x155ec8, 0x155ee0,
    0x156d4d, 0x156d80, 0x157ca8, 0x157cc0, 0x157d08, 0x157d20, 0x157da8, 0x157dc0, 0x1f63a1,
    0x1f63c8, 0x1f63e1, 0x1f6524, 0x1f6541, 0x1f6a02, 0x1fa7cd, 0x1faa02, 0x1fb9ed, 0x1fba09,
    0x1fbe02, 0x1fbfad, 0x1fc008, 0x1fc20d, 0x1fc340, 0x1fc408, 0x1fc60d, 0x1fca07, 0x1fca2d,
    0x1fca47, 0x1fca60, 0x1fca8d, 0x1fcaa7, 0x1fcacd, 0x1fcbe5, 0x1fcc0d, 0x1fcc44, 0x1fcc8d,
    0x1fcce0, 0x1fcd0d, 0x1fcd25, 0x1fcd6d, 0x1fcd80, 0x1fce02, 0x1fdfe9, 0x1fe000, 0x1fe02d,
    0x1fe065, 0x1fe0cd, 0x1fe164, 0x1fe187, 0x1fe1a4, 0x1fe1c7, 0x1fe203, 0x1fe347, 0x1fe36d,
    0x1fe420, 0x1fe76d, 0x1fe820, 0x1feb6d, 0x1fecc0, 0x1ffc05, 0x1ffc4d, 0x1ffca5, 0x1ffce0,
    0x1ffd0d, 0x1ffde0, 0x1ffe09, 0x1fff2d, 0x1fffc9, 0x200000, 0x20202d, 0x202040, 0x20280d,
    0x2031a0, 0x20320d, 0x2033a0, 0x20340d, 0x203420, 0x203fa8, 0x203fc0, 0x205c08, 0x205c23,
    0x205f80, 0x206ec8, 0x206f60, 0x210001, 0x2123ed, 0x212401, 0x214028, 0x214081, 0x2140a8,
    0x2140e1, 0x214188, 0x214201, 0x214708, 0x214761, 0x2147e8, 0x214801, 0x215ca8, 0x215ce1,
    0x21672d, 0x216801, 0x21a002, 0x21a488, 0x21a502, 0x21a606, 0x21a742, 0x21a801, 0x21cc06,
    0x21cfe1, 0x21d568, 0x21d5a1, 0x21d802, 0x21dfa8, 0x21e001, 0x21e602, 0x21e8c8, 0x21ea22,
    0x21ee01, 0x21f048, 0x21f0c1, 0x220000, 0x220028, 0x220040, 0x220708, 0x2208e0, 0x220a4d,
    0x220cc0, 0x220e08, 0x220e20, 0x220e68, 0x220ea0, 0x220fe8, 0x221040, 0x221668, 0x2216e0,
    0x221728, 0x221760, 0x221848, 0x221860, 0x222008, 0x222060, 0x2224e8, 0x222580, 0x2225a8,
    0x2226a0, 0x222e68, 0x222e80, 0x223008, 0x223040, 0x2236c8, 0x2237e0, 0x223928, 0x2239a0,
    0x2239e8, 0x223a00, 0x2245e8, 0x224640, 0x224688, 0x2246a0, 0x2246c8, 0x224700, 0x2247c8,
    0x2247e0, 0x224828, 0x224840, 0x225be8, 0x225c00, 0x225c68, 0x225d60, 0x226008, 0x226040,
    0x226768, 0x2267a0, 0x226808, 0x226820, 0x226cc8, 0x226da0, 0x226e08, 0x226ea0, 0x228708,
    0x228800, 0x228848, 0x2288a0, 0x2288c8, 0x2288e0, 0x228bc8, 0x228be0, 0x229668, 0x229720,
    0x229748, 0x229760, 0x2297e8, 0x229820, 0x229848, 0x229880, 0x22b648, 0x22b6c0, 0x22b788,
    0x22b7c0, 0x22b7e8, 0x22b820, 0x22bb88, 0x22bbc0, 0x22c668, 0x22c760, 0x22c7a8, 0x22c7c0,
    0x22c7e8, 0x22c820, 0x22cc0d, 0x22cda0, 0x22d568, 0x22d580, 0x22d5a8, 0x22d5c0, 0x22d608,
    0x22d6c0, 0x22d6e8, 0x22d700, 0x22e3a8, 0x22e400, 0x22e448, 0x22e4c0, 0x22e4e8, 0x22e580,
    0x2305e8, 0x230700, 0x230728, 0x230760, 0x232768, 0x2327a0, 0x2327c8, 0x2327e0, 0x232868,
    0x232880, 0x233a88, 0x233b00, 0x233b48, 0x233b80, 0x233c08, 0x233c20, 0x234028, 0x2340e0,
    0x234128, 0x234160, 0x234668, 0x234720, 0x234768, 0x2347e0, 0x2348e8, 0x234900, 0x234a28,
    0x234ae0, 0x234b28, 0x234b80, 0x235148, 0x2352e0, 0x235308, 0x235340, 0x238608, 0x2386e0,
    0x238708, 0x2387c0, 0x239248, 0x239500, 0x239548, 0x239620, 0x239648, 0x239680, 0x2396a8,
    0x2396e0, 0x23a628, 0x23a6e0, 0x23a748, 0x23a760, 0x23a788, 0x23a7c0, 0x23a7e8, 0x23a8c0,
    0x23a8e8, 0x23a900, 0x23b208, 0x23b240, 0x23b2a8, 0x23b2c0, 0x23b2e8, 0x23b300, 0x23de68,
    0x23dea0, 0x23e008, 0x23e040, 0x23e6c8, 0x23e760, 0x23e808, 0x23e820, 0x23e848, 0x23e860,
    0x23faad, 0x23fba5, 0x23fc2d, 0x23fe40, 0x268808, 0x268820, 0x2688e8, 0x268ac0, 0x2d5e08,
    0x2d5ea0, 0x2d6608, 0x2d66e0, 0x2de9e8, 0x2dea00, 0x2df1e8, 0x2df260, 0x2dfc4d, 0x2dfc60,
    0x2dfc88, 0x2dfca0, 0x3793a8, 0x3793e0, 0x379409, 0x379480, 0x39e008, 0x39e5c0, 0x39e608,
    0x39e8e0, 0x3a2ce8, 0x3a2d40, 0x3a2e69, 0x3a2f68, 0x3a3060, 0x3a30a8, 0x3a3180, 0x3a3548,
    0x3a35c0, 0x3a3d2d, 0x3a3d60, 0x3a400d, 0x3a4848, 0x3a48ad, 0x3a48c0, 0x3a600d, 0x3a6ae0,
    0x3adb6d, 0x3adb80, 0x3ae2ad, 0x3ae2c0, 0x3ae9ed, 0x3aea00, 0x3af12d, 0x3af140, 0x3af86d,
    0x3af880, 0x3af9c3, 0x3b0000, 0x3b4008, 0x3b46e0, 0x3b4768, 0x3b4da0, 0x3b4ea8, 0x3b4ec0,
    0x3b5088, 0x3b50a0, 0x3b5368, 0x3b5400, 0x3b5428, 0x3b5600, 0x3c0008, 0x3c00e0, 0x3c0108,
    0x3c0320, 0x3c0368, 0x3c0440, 0x3c0468, 0x3c04a0, 0x3c04c8, 0x3c0560, 0x3c11e8, 0x3c1200,
    0x3c2608, 0x3c26e0, 0x3c55c8, 0x3c55e0, 0x3c5d88, 0x3c5e00, 0x3c5fe5, 0x3c6000, 0x3c9d88,
    0x3c9e00, 0x3d0001, 0x3d1a08, 0x3d1ae1, 0x3d2888, 0x3d2961, 0x3d8e02, 0x3d9801, 0x3da002,
    0x3daa01, 0x3dc002, 0x3dde0d, 0x3dde42, 0x3de001, 0x3e000d, 0x3e0580, 0x3e060d, 0x3e1280,
    0x3e140d, 0x3e15e0, 0x3e162d, 0x3e1800, 0x3e182d, 0x3e1a00, 0x3e1a2d, 0x3e1ec0, 0x3e2003,
    0x3e216d, 0x3e2200, 0x3e25ed, 0x3e2600, 0x3e2d4d, 0x3e2e00, 0x3e35ad, 0x3e35c0, 0x3e4c0d,
    0x3e4cc0, 0x3e600d, 0x3edb00, 0x3edb8d, 0x3edda0, 0x3ede0d, 0x3edfa0, 0x3ee00d, 0x3eeee0,
    0x3eef6d, 0x3efb40, 0x3efc0d, 0x3efd80, 0x3efe0d, 0x3efe20, 0x3f000d, 0x3f0180, 0x3f020d,
    0x3f0900, 0x3f0a0d, 0x3f0b40, 0x3f0c0d, 0x3f1100, 0x3f120d, 0x3f15c0, 0x3f160d, 0x3f1640,
    0x3f200d, 0x3f4a80, 0x3f4c0d, 0x3f4dc0, 0x3f4e0d, 0x3f4fa0, 0x3f500d, 0x3f5120, 0x3f520d,
    0x3f57c0, 0x3f57ed, 0x3f58c0, 0x3f59cd, 0x3f5b80, 0x3f5c0d, 0x3f5d20, 0x3f5e0d, 0x3f5f20,
    0x3f600d, 0x3f7260, 0x3f728d, 0x3f7960, 0x3f7e03, 0x3f7f40, 0x3fffc9, 0x400000, 0x5fffc9,
    0x600000, 0x7fffc9, 0x800000, 0x9fffc9, 0xa00000, 0xbfffc9, 0xc00000, 0xdfffc9, 0xe00000,
    0xffffc9, 0x1000000, 0x11fffc9, 0x1200000, 0x13fffc9, 0x1400000, 0x15fffc9, 0x1600000, 0x17fffc9,
    0x1800000, 0x19fffc9, 0x1a00000, 0x1bfffc9, 0x1c02008, 0x1c03e09, 0x1c20000, 0x1dfffc9, 0x1e00000,
    0x1ffffc9, 0x2000000, 0x21fffc9,
};
/* BidiMirroring.txt: 428 pairs (code point, mirror), sorted. */
static const uint16_t BIDI_MIRROR[428][2] = {
    {0x0028, 0x0029}, {0x0029, 0x0028}, {0x003c, 0x003e}, {0x003e, 0x003c}, {0x005b, 0x005d}, {0x005d, 0x005b},
    {0x007b, 0x007d}, {0x007d, 0x007b}, {0x00ab, 0x00bb}, {0x00bb, 0x00ab}, {0x0f3a, 0x0f3b}, {0x0f3b, 0x0f3a},
    {0x0f3c, 0x0f3d}, {0x0f3d, 0x0f3c}, {0x169b, 0x169c}, {0x169c, 0x169b}, {0x2039, 0x203a}, {0x203a, 0x2039},
    {0x2045, 0x2046}, {0x2046, 0x2045}, {0x207d, 0x207e}, {0x207e, 0x207d}, {0x208d, 0x208e}, {0x208e, 0x208d},
    {0x2208, 0x220b}, {0x2209, 0x220c}, {0x220a, 0x220d}, {0x220b, 0x2208}, {0x220c, 0x2209}, {0x220d, 0x220a},
    {0x2215, 0x29f5}, {0x221f, 0x2bfe}, {0x2220, 0x29a3}, {0x2221, 0x299b}, {0x2222, 0x29a0}, {0x2224, 0x2aee},
    {0x223c, 0x223d}, {0x223d, 0x223c}, {0x2243, 0x22cd}, {0x2245, 0x224c}, {0x224c, 0x2245}, {0x2252, 0x2253},
    {0x2253, 0x2252}, {0x2254, 0x2255}, {0x2255, 0x2254}, {0x2264, 0x2265}, {0x2265, 0x2264}, {0x2266, 0x2267},
    {0x2267, 0x2266}, {0x2268, 0x2269}, {0x2269, 0x2268}, {0x226a, 0x226b}, {0x226b, 0x226a}, {0x226e, 0x226f},
    {0x226f, 0x226e}, {0x2270, 0x2271}, {0x2271, 0x2270}, {0x2272, 0x2273}, {0x2273, 0x2272}, {0x2274, 0x2275},
    {0x2275, 0x2274}, {0x2276, 0x2277}, {0x2277, 0x2276}, {0x2278, 0x2279}, {0x2279, 0x2278}, {0x227a, 0x227b},
    {0x227b, 0x227a}, {0x227c, 0x227d}, {0x227d, 0x227c}, {0x227e, 0x227f}, {0x227f, 0x227e}, {0x2280, 0x2281},
    {0x2281, 0x2280}, {0x2282, 0x2283}, {0x2283, 0x2282}, {0x2284, 0x2285}, {0x2285, 0x2284}, {0x2286, 0x2287},
    {0x2287, 0x2286}, {0x2288, 0x2289}, {0x2289, 0x2288}, {0x228a, 0x228b}, {0x228b, 0x228a}, {0x228f, 0x2290},
    {0x2290, 0x228f}, {0x2291, 0x2292}, {0x2292, 0x2291}, {0x2298, 0x29b8}, {0x22a2, 0x22a3}, {0x22a3, 0x22a2},
    {0x22a6, 0x2ade}, {0x22a8, 0x2ae4}, {0x22a9, 0x2ae3}, {0x22ab, 0x2ae5}, {0x22b0, 0x22b1}, {0x22b1, 0x22b0},
    {0x22b2, 0x22b3}, {0x22b3, 0x22b2}, {0x22b4, 0x22b5}, {0x22b5, 0x22b4}, {0x22b6, 0x22b7}, {0x22b7, 0x22b6},
    {0x22b8, 0x27dc}, {0x22c9, 0x22ca}, {0x22ca, 0x22c9}, {0x22cb, 0x22cc}, {0x22cc, 0x22cb}, {0x22cd, 0x2243},
    {0x22d0, 0x22d1}, {0x22d1, 0x22d0}, {0x22d6, 0x22d7}, {0x22d7, 0x22d6}, {0x22d8, 0x22d9}, {0x22d9, 0x22d8},
    {0x22da, 0x22db}, {0x22db, 0x22da}, {0x22dc, 0x22dd}, {0x22dd, 0x22dc}, {0x22de, 0x22df}, {0x22df, 0x22de},
    {0x22e0, 0x22e1}, {0x22e1, 0x22e0}, {0x22e2, 0x22e3}, {0x22e3, 0x22e2}, {0x22e4, 0x22e5}, {0x22e5, 0x22e4},
    {0x22e6, 0x22e7}, {0x22e7, 0x22e6}, {0x22e8, 0x22e9}, {0x22e9, 0x22e8}, {0x22ea, 0x22eb}, {0x22eb, 0x22ea},
    {0x22ec, 0x22ed}, {0x22ed, 0x22ec}, {0x22f0, 0x22f1}, {0x22f1, 0x22f0}, {0x22f2, 0x22fa}, {0x22f3, 0x22fb},
    {0x22f4, 0x22fc}, {0x22f6, 0x22fd}, {0x22f7, 0x22fe}, {0x22fa, 0x22f2}, {0x22fb, 0x22f3}, {0x22fc, 0x22f4},
    {0x22fd, 0x22f6}, {0x22fe, 0x22f7}, {0x2308, 0x2309}, {0x2309, 0x2308}, {0x230a, 0x230b}, {0x230b, 0x230a},
    {0x2329, 0x232a}, {0x232a, 0x2329}, {0x2768, 0x2769}, {0x2769, 0x2768}, {0x276a, 0x276b}, {0x276b, 0x276a},
    {0x276c, 0x276d}, {0x276d, 0x276c}, {0x276e, 0x276f}, {0x276f, 0x276e}, {0x2770, 0x2771}, {0x2771, 0x2770},
    {0x2772, 0x2773}, {0x2773, 0x2772}, {0x2774, 0x2775}, {0x2775, 0x2774}, {0x27c3, 0x27c4}, {0x27c4, 0x27c3},
    {0x27c5, 0x27c6}, {0x27c6, 0x27c5}, {0x27c8, 0x27c9}, {0x27c9, 0x27c8}, {0x27cb, 0x27cd}, {0x27cd, 0x27cb},
    {0x27d5, 0x27d6}, {0x27d6, 0x27d5}, {0x27dc, 0x22b8}, {0x27dd, 0x27de}, {0x27de, 0x27dd}, {0x27e2, 0x27e3},
    {0x27e3, 0x27e2}, {0x27e4, 0x27e5}, {0x27e5, 0x27e4}, {0x27e6, 0x27e7}, {0x27e7, 0x27e6}, {0x27e8, 0x27e9},
    {0x27e9, 0x27e8}, {0x27ea, 0x27eb}, {0x27eb, 0x27ea}, {0x27ec, 0x27ed}, {0x27ed, 0x27ec}, {0x27ee, 0x27ef},
    {0x27ef, 0x27ee}, {0x2983, 0x2984}, {0x2984, 0x2983}, {0x2985, 0x2986}, {0x2986, 0x2985}, {0x2987, 0x2988},
    {0x2988, 0x2987}, {0x2989, 0x298a}, {0x298a, 0x2989}, {0x298b, 0x298c}, {0x298c, 0x298b}, {0x298d, 0x2990},
    {0x298e, 0x298f}, {0x298f, 0x298e}, {0x2990, 0x298d}, {0x2991, 0x2992}, {0x2992, 0x2991}, {0x2993, 0x2994},
    {0x2994, 0x2993}, {0x2995, 0x2996}, {0x2996, 0x2995}, {0x2997, 0x2998}, {0x2998, 0x2997}, {0x299b, 0x2221},
    {0x29a0, 0x2222}, {0x29a3, 0x2220}, {0x29a4, 0x29a5}, {0x29a5, 0x29a4}, {0x29a8, 0x29a9}, {0x29a9, 0x29a8},
    {0x29aa, 0x29ab}, {0x29ab, 0x29aa}, {0x29ac, 0x29ad}, {0x29ad, 0x29ac}, {0x29ae, 0x29af}, {0x29af, 0x29ae},
    {0x29b8, 0x2298}, {0x29c0, 0x29c1}, {0x29c1, 0x29c0}, {0x29c4, 0x29c5}, {0x29c5, 0x29c4}, {0x29cf, 0x29d0},
    {0x29d0, 0x29cf}, {0x29d1, 0x29d2}, {0x29d2, 0x29d1}, {0x29d4, 0x29d5}, {0x29d5, 0x29d4}, {0x29d8, 0x29d9},
    {0x29d9, 0x29d8}, {0x29da, 0x29db}, {0x29db, 0x29da}, {0x29e8, 0x29e9}, {0x29e9, 0x29e8}, {0x29f5, 0x2215},
    {0x29f8, 0x29f9}, {0x29f9, 0x29f8}, {0x29fc, 0x29fd}, {0x29fd, 0x29fc}, {0x2a2b, 0x2a2c}, {0x2a2c, 0x2a2b},
    {0x2a2d, 0x2a2e}, {0x2a2e, 0x2a2d}, {0x2a34, 0x2a35}, {0x2a35, 0x2a34}, {0x2a3c, 0x2a3d}, {0x2a3d, 0x2a3c},
    {0x2a64, 0x2a65}, {0x2a65, 0x2a64}, {0x2a79, 0x2a7a}, {0x2a7a, 0x2a79}, {0x2a7b, 0x2a7c}, {0x2a7c, 0x2a7b},
    {0x2a7d, 0x2a7e}, {0x2a7e, 0x2a7d}, {0x2a7f, 0x2a80}, {0x2a80, 0x2a7f}, {0x2a81, 0x2a82}, {0x2a82, 0x2a81},
    {0x2a83, 0x2a84}, {0x2a84, 0x2a83}, {0x2a85, 0x2a86}, {0x2a86, 0x2a85}, {0x2a87, 0x2a88}, {0x2a88, 0x2a87},
    {0x2a89, 0x2a8a}, {0x2a8a, 0x2a89}, {0x2a8b, 0x2a8c}, {0x2a8c, 0x2a8b}, {0x2a8d, 0x2a8e}, {0x2a8e, 0x2a8d},
    {0x2a8f, 0x2a90}, {0x2a90, 0x2a8f}, {0x2a91, 0x2a92}, {0x2a92, 0x2a91}, {0x2a93, 0x2a94}, {0x2a94, 0x2a93},
    {0x2a95, 0x2a96}, {0x2a96, 0x2a95}, {0x2a97, 0x2a98}, {0x2a98, 0x2a97}, {0x2a99, 0x2a9a}, {0x2a9a, 0x2a99},
    {0x2a9b, 0x2a9c}, {0x2a9c, 0x2a9b}, {0x2a9d, 0x2a9e}, {0x2a9e, 0x2a9d}, {0x2a9f, 0x2aa0}, {0x2aa0, 0x2a9f},
    {0x2aa1, 0x2aa2}, {0x2aa2, 0x2aa1}, {0x2aa6, 0x2aa7}, {0x2aa7, 0x2aa6}, {0x2aa8, 0x2aa9}, {0x2aa9, 0x2aa8},
    {0x2aaa, 0x2aab}, {0x2aab, 0x2aaa}, {0x2aac, 0x2aad}, {0x2aad, 0x2aac}, {0x2aaf, 0x2ab0}, {0x2ab0, 0x2aaf},
    {0x2ab1, 0x2ab2}, {0x2ab2, 0x2ab1}, {0x2ab3, 0x2ab4}, {0x2ab4, 0x2ab3}, {0x2ab5, 0x2ab6}, {0x2ab6, 0x2ab5},
    {0x2ab7, 0x2ab8}, {0x2ab8, 0x2ab7}, {0x2ab9, 0x2aba}, {0x2aba, 0x2ab9}, {0x2abb, 0x2abc}, {0x2abc, 0x2abb},
    {0x2abd, 0x2abe}, {0x2abe, 0x2abd}, {0x2abf, 0x2ac0}, {0x2ac0, 0x2abf}, {0x2ac1, 0x2ac2}, {0x2ac2, 0x2ac1},
    {0x2ac3, 0x2ac4}, {0x2ac4, 0x2ac3}, {0x2ac5, 0x2ac6}, {0x2ac6, 0x2ac5}, {0x2ac7, 0x2ac8}, {0x2ac8, 0x2ac7},
    {0x2ac9, 0x2aca}, {0x2aca, 0x2ac9}, {0x2acb, 0x2acc}, {0x2acc, 0x2acb}, {0x2acd, 0x2ace}, {0x2ace, 0x2acd},
    {0x2acf, 0x2ad0}, {0x2ad0, 0x2acf}, {0x2ad1, 0x2ad2}, {0x2ad2, 0x2ad1}, {0x2ad3, 0x2ad4}, {0x2ad4, 0x2ad3},
    {0x2ad5, 0x2ad6}, {0x2ad6, 0x2ad5}, {0x2ade, 0x22a6}, {0x2ae3, 0x22a9}, {0x2ae4, 0x22a8}, {0x2ae5, 0x22ab},
    {0x2aec, 0x2aed}, {0x2aed, 0x2aec}, {0x2aee, 0x2224}, {0x2af7, 0x2af8}, {0x2af8, 0x2af7}, {0x2af9, 0x2afa},
    {0x2afa, 0x2af9}, {0x2bfe, 0x221f}, {0x2e02, 0x2e03}, {0x2e03, 0x2e02}, {0x2e04, 0x2e05}, {0x2e05, 0x2e04},
    {0x2e09, 0x2e0a}, {0x2e0a, 0x2e09}, {0x2e0c, 0x2e0d}, {0x2e0d, 0x2e0c}, {0x2e1c, 0x2e1d}, {0x2e1d, 0x2e1c},
    {0x2e20, 0x2e21}, {0x2e21, 0x2e20}, {0x2e22, 0x2e23}, {0x2e23, 0x2e22}, {0x2e24, 0x2e25}, {0x2e25, 0x2e24},
    {0x2e26, 0x2e27}, {0x2e27, 0x2e26}, {0x2e28, 0x2e29}, {0x2e29, 0x2e28}, {0x2e55, 0x2e56}, {0x2e56, 0x2e55},
    {0x2e57, 0x2e58}, {0x2e58, 0x2e57}, {0x2e59, 0x2e5a}, {0x2e5a, 0x2e59}, {0x2e5b, 0x2e5c}, {0x2e5c, 0x2e5b},
    {0x3008, 0x3009}, {0x3009, 0x3008}, {0x300a, 0x300b}, {0x300b, 0x300a}, {0x300c, 0x300d}, {0x300d, 0x300c},
    {0x300e, 0x300f}, {0x300f, 0x300e}, {0x3010, 0x3011}, {0x3011, 0x3010}, {0x3014, 0x3015}, {0x3015, 0x3014},
    {0x3016, 0x3017}, {0x3017, 0x3016}, {0x3018, 0x3019}, {0x3019, 0x3018}, {0x301a, 0x301b}, {0x301b, 0x301a},
    {0xfe59, 0xfe5a}, {0xfe5a, 0xfe59}, {0xfe5b, 0xfe5c}, {0xfe5c, 0xfe5b}, {0xfe5d, 0xfe5e}, {0xfe5e, 0xfe5d},
    {0xfe64, 0xfe65}, {0xfe65, 0xfe64}, {0xff08, 0xff09}, {0xff09, 0xff08}, {0xff1c, 0xff1e}, {0xff1e, 0xff1c},
    {0xff3b, 0xff3d}, {0xff3d, 0xff3b}, {0xff5b, 0xff5d}, {0xff5d, 0xff5b}, {0xff5f, 0xff60}, {0xff60, 0xff5f},
    {0xff62, 0xff63}, {0xff63, 0xff62},
};
/* BidiBrackets.txt: 128 brackets (code point, pair, 1 open / 2 close), sorted. */
static const uint16_t BIDI_BRACKET[128][3] = {
    {0x0028, 0x0029, 1}, {0x0029, 0x0028, 2}, {0x005b, 0x005d, 1}, {0x005d, 0x005b, 2}, {0x007b, 0x007d, 1},
    {0x007d, 0x007b, 2}, {0x0f3a, 0x0f3b, 1}, {0x0f3b, 0x0f3a, 2}, {0x0f3c, 0x0f3d, 1}, {0x0f3d, 0x0f3c, 2},
    {0x169b, 0x169c, 1}, {0x169c, 0x169b, 2}, {0x2045, 0x2046, 1}, {0x2046, 0x2045, 2}, {0x207d, 0x207e, 1},
    {0x207e, 0x207d, 2}, {0x208d, 0x208e, 1}, {0x208e, 0x208d, 2}, {0x2308, 0x2309, 1}, {0x2309, 0x2308, 2},
    {0x230a, 0x230b, 1}, {0x230b, 0x230a, 2}, {0x2329, 0x232a, 1}, {0x232a, 0x2329, 2}, {0x2768, 0x2769, 1},
    {0x2769, 0x2768, 2}, {0x276a, 0x276b, 1}, {0x276b, 0x276a, 2}, {0x276c, 0x276d, 1}, {0x276d, 0x276c, 2},
    {0x276e, 0x276f, 1}, {0x276f, 0x276e, 2}, {0x2770, 0x2771, 1}, {0x2771, 0x2770, 2}, {0x2772, 0x2773, 1},
    {0x2773, 0x2772, 2}, {0x2774, 0x2775, 1}, {0x2775, 0x2774, 2}, {0x27c5, 0x27c6, 1}, {0x27c6, 0x27c5, 2},
    {0x27e6, 0x27e7, 1}, {0x27e7, 0x27e6, 2}, {0x27e8, 0x27e9, 1}, {0x27e9, 0x27e8, 2}, {0x27ea, 0x27eb, 1},
    {0x27eb, 0x27ea, 2}, {0x27ec, 0x27ed, 1}, {0x27ed, 0x27ec, 2}, {0x27ee, 0x27ef, 1}, {0x27ef, 0x27ee, 2},
    {0x2983, 0x2984, 1}, {0x2984, 0x2983, 2}, {0x2985, 0x2986, 1}, {0x2986, 0x2985, 2}, {0x2987, 0x2988, 1},
    {0x2988, 0x2987, 2}, {0x2989, 0x298a, 1}, {0x298a, 0x2989, 2}, {0x298b, 0x298c, 1}, {0x298c, 0x298b, 2},
    {0x298d, 0x2990, 1}, {0x298e, 0x298f, 2}, {0x298f, 0x298e, 1}, {0x2990, 0x298d, 2}, {0x2991, 0x2992, 1},
    {0x2992, 0x2991, 2}, {0x2993, 0x2994, 1}, {0x2994, 0x2993, 2}, {0x2995, 0x2996, 1}, {0x2996, 0x2995, 2},
    {0x2997, 0x2998, 1}, {0x2998, 0x2997, 2}, {0x29d8, 0x29d9, 1}, {0x29d9, 0x29d8, 2}, {0x29da, 0x29db, 1},
    {0x29db, 0x29da, 2}, {0x29fc, 0x29fd, 1}, {0x29fd, 0x29fc, 2}, {0x2e22, 0x2e23, 1}, {0x2e23, 0x2e22, 2},
    {0x2e24, 0x2e25, 1}, {0x2e25, 0x2e24, 2}, {0x2e26, 0x2e27, 1}, {0x2e27, 0x2e26, 2}, {0x2e28, 0x2e29, 1},
    {0x2e29, 0x2e28, 2}, {0x2e55, 0x2e56, 1}, {0x2e56, 0x2e55, 2}, {0x2e57, 0x2e58, 1}, {0x2e58, 0x2e57, 2},
    {0x2e59, 0x2e5a, 1}, {0x2e5a, 0x2e59, 2}, {0x2e5b, 0x2e5c, 1}, {0x2e5c, 0x2e5b, 2}, {0x3008, 0x3009, 1},
    {0x3009, 0x3008, 2}, {0x300a, 0x300b, 1}, {0x300b, 0x300a, 2}, {0x300c, 0x300d, 1}, {0x300d, 0x300c, 2},
    {0x300e, 0x300f, 1}, {0x300f, 0x300e, 2}, {0x3010, 0x3011, 1}, {0x3011, 0x3010, 2}, {0x3014, 0x3015, 1},
    {0x3015, 0x3014, 2}, {0x3016, 0x3017, 1}, {0x3017, 0x3016, 2}, {0x3018, 0x3019, 1}, {0x3019, 0x3018, 2},
    {0x301a, 0x301b, 1}, {0x301b, 0x301a, 2}, {0xfe59, 0xfe5a, 1}, {0xfe5a, 0xfe59, 2}, {0xfe5b, 0xfe5c, 1},
    {0xfe5c, 0xfe5b, 2}, {0xfe5d, 0xfe5e, 1}, {0xfe5e, 0xfe5d, 2}, {0xff08, 0xff09, 1}, {0xff09, 0xff08, 2},
    {0xff3b, 0xff3d, 1}, {0xff3d, 0xff3b, 2}, {0xff5b, 0xff5d, 1}, {0xff5d, 0xff5b, 2}, {0xff5f, 0xff60, 1},
    {0xff60, 0xff5f, 2}, {0xff62, 0xff63, 1}, {0xff63, 0xff62, 2},
};
// clang-format on

/* ---- B1, B7: lookups ------------------------------------------------------ */

zui_bidi_class_t zui_bidi_class(uint32_t cp)
{
    if (cp > 0x10FFFFu) return ZUI_BIDI_L;
    uint32_t lo = 0, hi = (uint32_t) (sizeof BIDI_RANGES / sizeof BIDI_RANGES[0]);
    while (hi - lo > 1u) { /* the last range starting at or before cp */
        uint32_t mid = (lo + hi) / 2u;
        if ((BIDI_RANGES[mid] >> 5) <= cp)
            lo = mid;
        else
            hi = mid;
    }
    return (zui_bidi_class_t) (BIDI_RANGES[lo] & 31u);
}

const char *zui_bidi_class_name(zui_bidi_class_t c)
{
    static const char *const N[ZUI_BIDI_CLASS_COUNT] = {
        "L",  "R",  "AL",  "EN",  "ES",  "ET",  "AN",  "CS",  "NSM", "BN",  "B",  "S",
        "WS", "ON", "LRE", "LRO", "RLE", "RLO", "PDF", "LRI", "RLI", "FSI", "PDI"};
    return (unsigned) c < ZUI_BIDI_CLASS_COUNT ? N[c] : "?";
}

uint32_t zui_bidi_mirror(uint32_t cp)
{
    uint32_t lo = 0, hi = (uint32_t) (sizeof BIDI_MIRROR / sizeof BIDI_MIRROR[0]);
    while (lo < hi) {
        uint32_t mid = (lo + hi) / 2u;
        if (BIDI_MIRROR[mid][0] == cp) return BIDI_MIRROR[mid][1];
        if (BIDI_MIRROR[mid][0] < cp)
            lo = mid + 1u;
        else
            hi = mid;
    }
    return cp;
}

int zui_bidi_bracket(uint32_t cp, uint32_t *pair)
{
    uint32_t lo = 0, hi = (uint32_t) (sizeof BIDI_BRACKET / sizeof BIDI_BRACKET[0]);
    while (lo < hi) {
        uint32_t mid = (lo + hi) / 2u;
        if (BIDI_BRACKET[mid][0] == cp) {
            if (pair) *pair = BIDI_BRACKET[mid][1];
            return BIDI_BRACKET[mid][2];
        }
        if (BIDI_BRACKET[mid][0] < cp)
            lo = mid + 1u;
        else
            hi = mid;
    }
    if (pair) *pair = cp;
    return 0;
}

/* ---- UTF-8 ---------------------------------------------------------------- */

uint32_t zui_utf8_decode(const char *s, uint32_t len, uint32_t *i)
{
    const uint8_t *u = (const uint8_t *) s;
    uint32_t at = *i;
    uint8_t c = u[at];
    uint32_t need, cp, min2 = 0x80u, max2 = 0xBFu;
    if (c < 0x80u) {
        *i = at + 1u;
        return c;
    }
    if (c >= 0xC2u && c <= 0xDFu) {
        need = 1;
        cp = c & 0x1Fu;
    } else if (c >= 0xE0u && c <= 0xEFu) {
        need = 2;
        cp = c & 0x0Fu;
        if (c == 0xE0u) min2 = 0xA0u; /* overlong */
        if (c == 0xEDu) max2 = 0x9Fu; /* surrogates */
    } else if (c >= 0xF0u && c <= 0xF4u) {
        need = 3;
        cp = c & 0x07u;
        if (c == 0xF0u) min2 = 0x90u;
        if (c == 0xF4u) max2 = 0x8Fu;
    } else {
        *i = at + 1u;
        return 0xFFFDu;
    }
    if (len - at <= need) {
        *i = at + 1u;
        return 0xFFFDu;
    }
    for (uint32_t k = 1; k <= need; k++) {
        uint8_t d = u[at + k];
        if (d < (k == 1 ? min2 : 0x80u) || d > (k == 1 ? max2 : 0xBFu)) {
            *i = at + 1u;
            return 0xFFFDu;
        }
        cp = (cp << 6) | (d & 0x3Fu);
    }
    *i = at + need + 1u;
    return cp;
}

uint32_t zui_utf8_encode(uint32_t cp, char *out, uint32_t cap)
{
    uint8_t *o = (uint8_t *) out;
    if (cp > 0x10FFFFu || (cp >= 0xD800u && cp <= 0xDFFFu)) cp = 0xFFFDu;
    if (cp < 0x80u) {
        if (cap < 1u) return 0;
        o[0] = (uint8_t) cp;
        return 1;
    }
    if (cp < 0x800u) {
        if (cap < 2u) return 0;
        o[0] = (uint8_t) (0xC0u | (cp >> 6));
        o[1] = (uint8_t) (0x80u | (cp & 0x3Fu));
        return 2;
    }
    if (cp < 0x10000u) {
        if (cap < 3u) return 0;
        o[0] = (uint8_t) (0xE0u | (cp >> 12));
        o[1] = (uint8_t) (0x80u | ((cp >> 6) & 0x3Fu));
        o[2] = (uint8_t) (0x80u | (cp & 0x3Fu));
        return 3;
    }
    if (cap < 4u) return 0;
    o[0] = (uint8_t) (0xF0u | (cp >> 18));
    o[1] = (uint8_t) (0x80u | ((cp >> 12) & 0x3Fu));
    o[2] = (uint8_t) (0x80u | ((cp >> 6) & 0x3Fu));
    o[3] = (uint8_t) (0x80u | (cp & 0x3Fu));
    return 4;
}

/* ---- helpers -------------------------------------------------------------- */

static bool is_isolate_init(uint8_t t)
{
    return t == LRI || t == RLI || t == FSI;
}
static bool is_removed_class(uint8_t t) /* X9 */
{
    return t == RLE || t == LRE || t == RLO || t == LRO || t == PDF || t == BN;
}
static bool is_ni(uint8_t t) /* neutral or isolate formatting character */
{
    return t == B || t == S || t == WS || t == ON || t == LRI || t == RLI || t == FSI || t == PDI;
}
/* L, R or none (EN and AN count as R): the strong direction for N0..N2. */
static int strong_nx(uint8_t t)
{
    if (t == L) return L;
    if (t == R || t == AL || t == EN || t == AN) return R;
    return -1;
}

/* P2, P3 on [from, to): 0 (L), 1 (R or AL) or -1 (no strong character). */
static int first_strong(const zui_bidi_t *b, uint32_t from, uint32_t to)
{
    for (uint32_t i = from; i < to; i++) {
        uint8_t t = b->cls[i];
        if (t == L) return 0;
        if (t == R || t == AL) return 1;
        if (is_isolate_init(t)) {
            if (b->match[i] == NONE) return -1; /* the isolate runs to the end */
            i = b->match[i];
        }
    }
    return -1;
}

/* BD9: matching isolate initiators and PDIs. */
static void match_isolates(zui_bidi_t *b)
{
    uint16_t *stack = b->seq; /* free at this point */
    uint32_t sp = 0;
    for (uint32_t i = 0; i < b->n; i++) {
        b->match[i] = NONE;
        if (is_isolate_init(b->cls[i])) {
            stack[sp++] = (uint16_t) i;
        } else if (b->cls[i] == PDI && sp) {
            uint16_t o = stack[--sp];
            b->match[o] = (uint16_t) i;
            b->match[i] = o;
        }
    }
}

/* ---- B4: X1..X8 ----------------------------------------------------------- */

static void explicit_levels(zui_bidi_t *b)
{
    uint8_t lvl[ZUI_BIDI_DEPTH + 2u], ovr[ZUI_BIDI_DEPTH + 2u];
    bool iso[ZUI_BIDI_DEPTH + 2u];
    uint32_t top = 0, over_iso = 0, over_emb = 0, valid_iso = 0;
    lvl[0] = b->para_level;
    ovr[0] = ON;
    iso[0] = false;
    for (uint32_t i = 0; i < b->n; i++) {
        uint8_t t = b->cls[i];
        b->type[i] = t;
        b->removed[i] = false;
        switch (t) {
        case RLE:
        case LRE:
        case RLO:
        case LRO: {
            uint32_t nl = (t == RLE || t == RLO) ? ((lvl[top] + 1u) | 1u) : ((lvl[top] + 2u) & ~1u);
            if (nl <= ZUI_BIDI_DEPTH && over_iso == 0 && over_emb == 0) {
                top++;
                lvl[top] = (uint8_t) nl;
                ovr[top] = t == RLO ? R : t == LRO ? L : ON;
                iso[top] = false;
            } else if (over_iso == 0) {
                over_emb++;
            }
            b->removed[i] = true;
            b->level[i] = lvl[top];
            break;
        }
        case RLI:
        case LRI:
        case FSI: {
            bool rtl = t == RLI;
            if (t == FSI) {
                uint32_t to = b->match[i] == NONE ? b->n : b->match[i];
                rtl = first_strong(b, i + 1u, to) == 1;
            }
            b->level[i] = lvl[top];
            if (ovr[top] != ON) b->type[i] = ovr[top];
            uint32_t nl = rtl ? ((lvl[top] + 1u) | 1u) : ((lvl[top] + 2u) & ~1u);
            if (nl <= ZUI_BIDI_DEPTH && over_iso == 0 && over_emb == 0) {
                valid_iso++;
                top++;
                lvl[top] = (uint8_t) nl;
                ovr[top] = ON;
                iso[top] = true;
            } else {
                over_iso++;
            }
            break;
        }
        case PDI:
            if (over_iso > 0) {
                over_iso--;
            } else if (valid_iso > 0) {
                over_emb = 0;
                while (!iso[top]) top--;
                top--;
                valid_iso--;
            }
            b->level[i] = lvl[top];
            if (ovr[top] != ON) b->type[i] = ovr[top];
            break;
        case PDF:
            if (over_iso > 0) {
                /* nothing */
            } else if (over_emb > 0) {
                over_emb--;
            } else if (!iso[top] && top > 0) {
                top--;
            }
            b->removed[i] = true;
            b->level[i] = lvl[top];
            break;
        case B:
            b->level[i] = b->para_level;
            break;
        case BN:
            b->removed[i] = true;
            b->level[i] = lvl[top];
            break;
        default:
            b->level[i] = lvl[top];
            if (ovr[top] != ON) b->type[i] = ovr[top];
            break;
        }
    }
}

/* ---- B5: one isolating run sequence --------------------------------------- */

static void insertion_sort_pairs(zui_bidi_t *b, uint32_t np)
{
    for (uint32_t i = 1; i < np; i++) {
        uint16_t o = b->pair_o[i], c = b->pair_c[i];
        uint32_t j = i;
        while (j > 0 && b->pair_o[j - 1u] > o) {
            b->pair_o[j] = b->pair_o[j - 1u];
            b->pair_c[j] = b->pair_c[j - 1u];
            j--;
        }
        b->pair_o[j] = o;
        b->pair_c[j] = c;
    }
}

/* Closing brackets compared up to canonical equivalence (U+232A is U+3009;
 * only closers are compared: an opener is matched through its pair). */
static uint32_t canon_bracket(uint32_t cp)
{
    return cp == 0x232Au ? 0x3009u : cp;
}

/* N0: pair_o/pair_c hold positions in seq[]. */
static void resolve_brackets(zui_bidi_t *b, uint32_t m, uint8_t sos, uint8_t e)
{
    const uint16_t *q = b->seq;
    uint16_t open_k[ZUI_BIDI_BRACKETS];
    uint32_t open_cp[ZUI_BIDI_BRACKETS];
    uint32_t sp = 0, np = 0;
    for (uint32_t k = 0; k < m; k++) {
        uint32_t i = q[k], pair;
        if (b->type[i] != ON) continue;
        int kind = zui_bidi_bracket(b->cp[i], &pair);
        if (kind == 1) {
            if (sp == ZUI_BIDI_BRACKETS) break; /* BD16: stop for this sequence */
            open_k[sp] = (uint16_t) k;
            open_cp[sp] = canon_bracket(pair); /* the closer it waits for */
            sp++;
        } else if (kind == 2) {
            uint32_t want = canon_bracket(b->cp[i]);
            for (uint32_t s = sp; s-- > 0;) {
                if (open_cp[s] == want) {
                    b->pair_o[np] = open_k[s];
                    b->pair_c[np] = (uint16_t) k;
                    np++;
                    sp = s;
                    break;
                }
            }
        }
    }
    insertion_sort_pairs(b, np);
    for (uint32_t p = 0; p < np; p++) {
        uint32_t o = b->pair_o[p], c = b->pair_c[p];
        bool has_e = false, has_opp = false;
        for (uint32_t k = o + 1u; k < c; k++) {
            int d = strong_nx(b->type[q[k]]);
            if (d < 0) continue;
            if (d == e)
                has_e = true;
            else
                has_opp = true;
        }
        int nt = -1;
        if (has_e) {
            nt = e;
        } else if (has_opp) {
            int before = sos;
            for (uint32_t k = o; k-- > 0;) {
                int d = strong_nx(b->type[q[k]]);
                if (d >= 0) {
                    before = d;
                    break;
                }
            }
            nt = before != e ? before : e;
        }
        if (nt < 0) continue;
        uint32_t ends[2] = {o, c};
        for (int j = 0; j < 2; j++) {
            b->type[q[ends[j]]] = (uint8_t) nt;
            for (uint32_t k = ends[j] + 1u; k < m && b->cls[q[k]] == NSM; k++)
                b->type[q[k]] = (uint8_t) nt;
        }
    }
}

static void resolve_sequence(zui_bidi_t *b, uint32_t m)
{
    uint16_t *q = b->seq;
    uint8_t lev = b->level[q[0]];
    /* sos, eos (X10) */
    uint32_t first = q[0], last = q[m - 1u];
    uint8_t prev = b->para_level, next = b->para_level;
    for (uint32_t i = first; i-- > 0;) {
        if (!b->removed[i]) {
            prev = b->level[i];
            break;
        }
    }
    if (!is_isolate_init(b->type[last])) {
        for (uint32_t i = last + 1u; i < b->n; i++) {
            if (!b->removed[i]) {
                next = b->level[i];
                break;
            }
        }
    }
    uint8_t sos = ((prev > lev ? prev : lev) & 1u) ? R : L;
    uint8_t eos = ((next > lev ? next : lev) & 1u) ? R : L;

    /* W1 */
    for (uint32_t k = 0; k < m; k++) {
        if (b->type[q[k]] != NSM) continue;
        if (k == 0) {
            b->type[q[k]] = sos;
        } else {
            uint8_t p = b->type[q[k - 1u]];
            b->type[q[k]] = (is_isolate_init(p) || p == PDI) ? ON : p;
        }
    }
    /* W2, W3 */
    uint8_t strong = sos;
    for (uint32_t k = 0; k < m; k++) {
        uint8_t t = b->type[q[k]];
        if (t == L || t == R || t == AL) strong = t;
        if (t == EN && strong == AL) b->type[q[k]] = AN;
    }
    for (uint32_t k = 0; k < m; k++)
        if (b->type[q[k]] == AL) b->type[q[k]] = R;
    /* W4 */
    for (uint32_t k = 1; k + 1u < m; k++) {
        uint8_t t = b->type[q[k]], a = b->type[q[k - 1u]], c = b->type[q[k + 1u]];
        if (t == ES && a == EN && c == EN)
            b->type[q[k]] = EN;
        else if (t == CS && a == EN && c == EN)
            b->type[q[k]] = EN;
        else if (t == CS && a == AN && c == AN)
            b->type[q[k]] = AN;
    }
    /* W5 */
    for (uint32_t k = 0; k < m;) {
        if (b->type[q[k]] != ET) {
            k++;
            continue;
        }
        uint32_t e = k;
        while (e < m && b->type[q[e]] == ET) e++;
        bool en = (k > 0 && b->type[q[k - 1u]] == EN) || (e < m && b->type[q[e]] == EN);
        if (en)
            for (uint32_t j = k; j < e; j++) b->type[q[j]] = EN;
        k = e;
    }
    /* W6 */
    for (uint32_t k = 0; k < m; k++) {
        uint8_t t = b->type[q[k]];
        if (t == ES || t == ET || t == CS) b->type[q[k]] = ON;
    }
    /* W7 */
    strong = sos;
    for (uint32_t k = 0; k < m; k++) {
        uint8_t t = b->type[q[k]];
        if (t == L || t == R) strong = t;
        if (t == EN && strong == L) b->type[q[k]] = L;
    }
    /* N0 */
    uint8_t e = (lev & 1u) ? R : L;
    resolve_brackets(b, m, sos, e);
    /* N1, N2 */
    for (uint32_t k = 0; k < m;) {
        if (!is_ni(b->type[q[k]])) {
            k++;
            continue;
        }
        uint32_t end = k;
        while (end < m && is_ni(b->type[q[end]])) end++;
        int before = k == 0 ? sos : strong_nx(b->type[q[k - 1u]]);
        int after = end == m ? eos : strong_nx(b->type[q[end]]);
        uint8_t nt = (before == after && before >= 0) ? (uint8_t) before : e;
        for (uint32_t j = k; j < end; j++) b->type[q[j]] = nt;
        k = end;
    }
}

/* X10: level runs, then each isolating run sequence (BD13). */
static void implicit_levels(zui_bidi_t *b)
{
    uint32_t nr = 0;
    int last_level = -1;
    for (uint32_t i = 0; i < b->n; i++) {
        if (b->removed[i]) continue;
        if (b->level[i] != last_level) {
            b->run_lo[nr] = (uint16_t) i;
            nr++;
            last_level = b->level[i];
        }
        b->run[i] = (uint16_t) (nr - 1u);
        b->run_hi[nr - 1u] = (uint16_t) i;
    }
    for (uint32_t r = 0; r < nr; r++) {
        uint32_t f = b->run_lo[r];
        if (b->cls[f] == PDI && b->match[f] != NONE) continue; /* continues a sequence */
        uint32_t m = 0, cur = r;
        for (;;) {
            for (uint32_t i = b->run_lo[cur]; i <= b->run_hi[cur]; i++)
                if (!b->removed[i]) b->seq[m++] = (uint16_t) i;
            uint32_t l = b->run_hi[cur];
            if (!is_isolate_init(b->cls[l]) || b->match[l] == NONE) break;
            cur = b->run[b->match[l]];
        }
        resolve_sequence(b, m);
    }
    /* I1, I2: after every sequence, so sos and eos above saw explicit levels */
    for (uint32_t i = 0; i < b->n; i++) {
        uint8_t t = b->type[i];
        if (b->removed[i]) continue;
        if (!(b->level[i] & 1u)) {
            if (t == R)
                b->level[i] += 1u;
            else if (t == AN || t == EN)
                b->level[i] += 2u;
        } else if (t == L || t == EN || t == AN) {
            b->level[i] += 1u;
        }
    }
    /* the removed characters draw at the level before them */
    for (uint32_t i = 0; i < b->n; i++)
        if (b->removed[i]) b->level[i] = i ? b->level[i - 1u] : b->para_level;
}

/* ---- B2, B3: a paragraph -------------------------------------------------- */

uint32_t zui_bidi_paragraph(zui_bidi_t *b, const char *utf8, uint32_t len, zui_bidi_dir_t dir)
{
    uint32_t i = 0, n = 0, end_kept = 0;
    b->truncated = false;
    while (utf8 && i < len) {
        uint32_t at = i;
        uint32_t cp = zui_utf8_decode(utf8, len, &i);
        uint8_t c = (uint8_t) zui_bidi_class(cp);
        if (n < ZUI_BIDI_MAX) {
            b->cp[n] = cp;
            b->off[n] = at;
            b->cls[n] = c;
            n++;
            end_kept = i;
        } else {
            b->truncated = true;
        }
        if (c == B) break;
    }
    b->n = n;
    b->bytes = i;
    b->off[n] = end_kept;
    match_isolates(b);
    if (dir == ZUI_BIDI_AUTO) {
        int f = first_strong(b, 0, n);
        b->para_level = f == 1 ? 1u : 0u;
    } else {
        b->para_level = dir == ZUI_BIDI_RTL ? 1u : 0u;
    }
    explicit_levels(b);
    implicit_levels(b);
    return b->bytes;
}

/* ---- B6: a line ------------------------------------------------------------ */

static bool l1_trailing(const zui_bidi_t *b, uint32_t i)
{
    uint8_t c = b->cls[i];
    return c == WS || is_isolate_init(c) || c == PDI || is_removed_class(c);
}

uint32_t zui_bidi_line(const zui_bidi_t *b, uint32_t start, uint32_t end, uint8_t *levels,
                       uint16_t *order, bool keep_removed)
{
    uint8_t lv[ZUI_BIDI_MAX];
    if (end > b->n) end = b->n;
    if (start >= end) return 0;
    uint32_t n = end - start;
    /* L1 */
    for (uint32_t k = 0; k < n; k++) lv[k] = b->level[start + k];
    bool tail = true; /* walking back from the end of the line */
    for (uint32_t k = n; k-- > 0;) {
        uint8_t c = b->cls[start + k];
        if (c == S || c == B) {
            lv[k] = b->para_level;
            tail = true;
        } else if (tail && l1_trailing(b, start + k)) {
            lv[k] = b->para_level;
        } else {
            tail = false;
        }
    }
    if (levels)
        for (uint32_t k = 0; k < n; k++) levels[k] = lv[k];
    if (!order) return 0;
    /* L2 */
    uint32_t cnt = 0;
    uint8_t hi = 0, lo_odd = 0xFF;
    for (uint32_t k = 0; k < n; k++) {
        if (!keep_removed && b->removed[start + k]) continue;
        order[cnt++] = (uint16_t) (start + k);
        if (lv[k] > hi) hi = lv[k];
        if ((lv[k] & 1u) && lv[k] < lo_odd) lo_odd = lv[k];
    }
    for (uint32_t L2 = hi; L2 >= lo_odd && L2 > 0; L2--) {
        for (uint32_t v = 0; v < cnt;) {
            if (lv[order[v] - start] < L2) {
                v++;
                continue;
            }
            uint32_t e = v;
            while (e < cnt && lv[order[e] - start] >= L2) e++;
            for (uint32_t a = v, z = e - 1u; a < z; a++, z--) {
                uint16_t t = order[a];
                order[a] = order[z];
                order[z] = t;
            }
            v = e;
        }
    }
    return cnt;
}

/* ---- B8 ------------------------------------------------------------------- */

uint32_t zui_bidi_visual(const zui_bidi_t *b, uint32_t start, uint32_t end, char *out, uint32_t cap)
{
    uint16_t order[ZUI_BIDI_MAX];
    uint8_t lv[ZUI_BIDI_MAX];
    uint32_t w = 0;
    if (!out || cap == 0) return 0;
    if (end > b->n) end = b->n;
    uint32_t cnt = zui_bidi_line(b, start, end, lv, order, false);
    for (uint32_t v = 0; v < cnt;) {
        uint32_t i = order[v];
        uint32_t from = v, to = v + 1u; /* emit order[from..to) */
        bool flip = false;
        /* L3-like: in a right-to-left run the marks have come out before their
         * base; put the base first again so a plain drawer stacks them. */
        if ((lv[i - start] & 1u) && b->cls[i] == NSM) {
            uint32_t j = v;
            while (j < cnt && b->cls[order[j]] == NSM && (lv[order[j] - start] & 1u)) j++;
            if (j < cnt) {
                to = j + 1u;
                flip = true;
            }
        }
        for (uint32_t k = 0; k < to - from; k++) {
            uint32_t at = flip ? order[to - 1u - k] : order[from + k];
            uint32_t cp = b->cp[at];
            if (lv[at - start] & 1u) cp = zui_bidi_mirror(cp);
            uint32_t len = zui_utf8_encode(cp, out + w, cap - 1u - w);
            if (!len) {
                out[w] = 0;
                return w;
            }
            w += len;
        }
        v = to;
    }
    out[w] = 0;
    return w;
}
